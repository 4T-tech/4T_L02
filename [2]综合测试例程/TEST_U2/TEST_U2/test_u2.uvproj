# Keil uVision project test_u2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: test_u2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\TEST_U2
  group Source Group 1
    ./: main.c iic.c at24c02.c STARTUP.A51 ds1302.c pcf8591.c
